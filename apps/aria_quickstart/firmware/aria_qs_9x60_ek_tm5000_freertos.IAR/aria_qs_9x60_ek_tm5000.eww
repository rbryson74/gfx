<?xml version='1.0' encoding='utf-8'?>
<workspace>
    <project>
        <path>$WS_DIR$\aria_qs_9x60_ek_tm5000.ewp</path>
    </project>
</workspace>
