# IAR project legato_qs_e54_cult_cpro_parallel.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAME54P20A Microchip ATSAME54P20A
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCIncludePath2: ..\..\firmware\src; ..\..\firmware\src\config\ili9488_rgb565_e54_cult_parallel_iar; ..\..\firmware\src\packs\ATSAME54P20A_DFP; ..\..\firmware\src\packs\CMSIS\CMSIS\Core\Include; ..\..\firmware\src\packs\CMSIS; ..\..\firmware\src\arm
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: legato_qs_e54_cult_cpro_parallel.srec
  ILINK.IlinkOutputFile: legato_qs_e54_cult_cpro_parallel.out
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/: ili9488_rgb565_e54_cult_parallel_iar.ipcf
  group IAR Project Connection File/Header Files
    ../src/packs/ATSAME54P20A_DFP/component/: ac.h adc.h aes.h can.h ccl.h cmcc.h dac.h dmac.h dsu.h eic.h evsys.h freqm.h gclk.h gmac.h hmatrixb.h i2s.h icm.h mclk.h nvmctrl.h osc32kctrl.h oscctrl.h pac.h pcc.h pdec.h pm.h port.h pukcc.h qspi.h ramecc.h rstc.h rtc.h sdhc.h sercom.h supc.h tc.h tcc.h trng.h usb.h wdt.h
    ../src/: app.h
    ../src/packs/ATSAME54P20A_DFP/: atsame54p20a.h device.h
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/bsp/: bsp.h
    ../src/packs/CMSIS/CMSIS/Core/Include/: cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm4.h mpu_armv7.h
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/: configuration.h definitions.h device_cache.h toolchain_specifics.h user.h
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/driver/: driver.h driver_common.h
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/gfx/interface/: drv_gfx_disp_intf.h
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/gfx/driver/controller/ili9488/: drv_gfx_ili9488.h drv_gfx_ili9488_cmd_defs.h
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/driver/i2c/: drv_i2c.h drv_i2c_definitions.h
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/driver/input/: drv_maxtouch.h
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/gfx/driver/: gfx_driver.h
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/gfx/legato/generated/: le_gen_assets.h le_gen_harmony.h le_gen_init.h le_gen_scheme.h
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/gfx/legato/generated/screen/: le_gen_screen_Screen0.h
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/gfx/legato/: legato.h legato_config.h
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/gfx/legato/datastructure/: legato_array.h legato_list.h legato_rectarray.h
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/gfx/legato/common/: legato_color.h legato_common.h legato_error.h legato_math.h legato_pixelbuffer.h legato_rect.h legato_utils.h
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/gfx/legato/string/: legato_dynamicstring.h legato_fixedstring.h legato_string.h legato_string_renderer.h legato_stringtable.h legato_stringutils.h legato_tablestring.h
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/gfx/legato/widget/: legato_editwidget.h legato_widget.h legato_widget_skin_classic_common.h
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/gfx/legato/core/: legato_event.h legato_input.h legato_scheme.h legato_state.h legato_stream.h
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/gfx/legato/memory/: legato_fixedheap.h legato_memory.h legato_variableheap.h
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/gfx/legato/font/: legato_font.h
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/gfx/legato/image/: legato_image.h legato_image_utils.h legato_palette.h
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/gfx/legato/image/raw/: legato_imagedecoder_raw.h
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/gfx/legato/widget/radiobutton/: legato_radiobutton_group.h legato_widget_radiobutton.h
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/gfx/legato/renderer/: legato_renderer.h
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/gfx/legato/widget/arc/: legato_widget_arc.h
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/gfx/legato/widget/bargraph/: legato_widget_bar_graph.h
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/gfx/legato/widget/button/: legato_widget_button.h
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/gfx/legato/widget/checkbox/: legato_widget_checkbox.h
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/gfx/legato/widget/circle/: legato_widget_circle.h
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/gfx/legato/widget/circulargauge/: legato_widget_circular_gauge.h
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/gfx/legato/widget/circularslider/: legato_widget_circular_slider.h
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/gfx/legato/widget/drawsurface/: legato_widget_drawsurface.h
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/gfx/legato/widget/gradient/: legato_widget_gradient.h
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/gfx/legato/widget/groupbox/: legato_widget_groupbox.h
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/gfx/legato/widget/image/: legato_widget_image.h
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/gfx/legato/widget/imagerotate/: legato_widget_imagerotate.h
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/gfx/legato/widget/imagescale/: legato_widget_imagescale.h
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/gfx/legato/widget/imagesequence/: legato_widget_imagesequence.h
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/gfx/legato/widget/keypad/: legato_widget_keypad.h
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/gfx/legato/widget/label/: legato_widget_label.h
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/gfx/legato/widget/line/: legato_widget_line.h
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/gfx/legato/widget/linegraph/: legato_widget_line_graph.h
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/gfx/legato/widget/list/: legato_widget_list.h
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/gfx/legato/widget/listwheel/: legato_widget_listwheel.h
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/gfx/legato/widget/piechart/: legato_widget_pie_chart.h
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/gfx/legato/widget/progressbar/: legato_widget_progressbar.h
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/gfx/legato/widget/radialmenu/: legato_widget_radial_menu.h
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/gfx/legato/widget/rectangle/: legato_widget_rectangle.h
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/gfx/legato/widget/scrollbar/: legato_widget_scrollbar.h
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/gfx/legato/widget/slider/: legato_widget_slider.h
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/gfx/legato/widget/textfield/: legato_widget_textfield.h
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/gfx/legato/widget/touchtest/: legato_widget_touchtest.h
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/gfx/legato/widget/window/: legato_widget_window.h
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/osal/: osal.h osal_definitions.h osal_impl_basic.h
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/peripheral/ccl/: plib_ccl.h
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/peripheral/clock/: plib_clock.h
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/peripheral/cmcc/: plib_cmcc.h
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/peripheral/dmac/: plib_dmac.h
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/peripheral/evsys/: plib_evsys.h
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/peripheral/nvic/: plib_nvic.h
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/peripheral/nvmctrl/: plib_nvmctrl.h
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/peripheral/port/: plib_port.h
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/peripheral/sercom/i2c_master/: plib_sercom4_i2c_master.h plib_sercom_i2c_master_common.h
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/peripheral/tc/: plib_tc0.h plib_tc_common.h
    ../src/packs/ATSAME54P20A_DFP/pio/: same54p20a.h
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/system/cache/: sys_cache.h
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/system/input/: sys_input.h sys_input_gesture.h sys_input_keyboard.h sys_input_listener.h sys_input_mouse.h sys_input_touch.h
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/system/int/: sys_int.h sys_int_mapping.h
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/system/time/: sys_time.h sys_time_definitions.h
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/system/time/src/: sys_time_local.h
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/system/: system.h system_common.h system_module.h
  group IAR Project Connection File/Source Files
    ../src/: app.c main.c
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/bsp/: bsp.c
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/gfx/interface/parallel_portgroup/: drv_gfx_disp_intf_parallel_portgroup_dma.c
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/gfx/driver/controller/ili9488/: drv_gfx_ili9488.c
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/driver/i2c/src/: drv_i2c.c drv_i2c_local.h
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/driver/input/: drv_maxtouch.c
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/: exceptions.c initialization.c interrupts.c startup_iar.c tasks.c
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/gfx/driver/: gfx_driver.c
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/stdio/: iar_monitor.c
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/gfx/legato/generated/font/: le_gen_font_NotoSans_Medium.c
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/gfx/legato/generated/: le_gen_harmony.c le_gen_init.c le_gen_scheme.c le_gen_stringtable.c
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/gfx/legato/generated/image/: le_gen_image_MHGC_170x170.c
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/gfx/legato/generated/screen/: le_gen_screen_Screen0.c
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/gfx/legato/datastructure/: legato_array.c legato_list.c legato_rectarray.c
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/gfx/legato/common/: legato_color.c legato_color_blend.c legato_color_convert.c legato_color_lerp.c legato_color_value.c legato_error.c legato_math.c legato_pixelbuffer.c legato_rect.c legato_utils.c
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/gfx/legato/renderer/: legato_draw.c legato_draw_arc.c legato_draw_line.c legato_draw_rect.c legato_renderer.c
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/gfx/legato/string/: legato_dynamicstring.c legato_fixedstring.c legato_string.c legato_string_renderer.c legato_string_renderer_stream.c legato_stringtable.c legato_stringutils.c legato_tablestring.c
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/gfx/legato/widget/: legato_editwidget.c legato_widget.c legato_widget_skin_classic.c legato_widget_skin_classic_common.c
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/gfx/legato/core/: legato_event.c legato_input.c legato_scheme.c legato_state.c legato_stream.c
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/gfx/legato/memory/: legato_fixedheap.c legato_memory.c legato_variableheap.c
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/gfx/legato/font/: legato_font.c legato_rasterfont_liberationmono1.c legato_rasterfont_liberationmono8.c legato_rasterfont_stream.c
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/gfx/legato/image/: legato_image.c legato_image_utils.c legato_palette.c
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/gfx/legato/image/raw/: legato_imagedecoder_raw.c legato_imagedecoder_raw_blend.c legato_imagedecoder_raw_convert.c legato_imagedecoder_raw_mask.c legato_imagedecoder_raw_palette_internal.c legato_imagedecoder_raw_palette_stream.c legato_imagedecoder_raw_read_internal.c legato_imagedecoder_raw_read_stream_color.c legato_imagedecoder_raw_read_stream_index.c legato_imagedecoder_raw_read_stream_rlecolor.c legato_imagedecoder_raw_read_stream_rleindex.c legato_imagedecoder_raw_rotate.c legato_imagedecoder_raw_scale.c legato_imagedecoder_raw_setup.c legato_imagedecoder_raw_write.c
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/gfx/legato/widget/radiobutton/: legato_radiobutton_group.c legato_widget_radiobutton.c legato_widget_radiobutton_skin_classic.c
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/gfx/legato/widget/arc/: legato_widget_arc.c legato_widget_arc_skin_classic.c
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/gfx/legato/widget/bargraph/: legato_widget_bar_graph.c legato_widget_bar_graph_skin_classic.c
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/gfx/legato/widget/button/: legato_widget_button.c legato_widget_button_skin_classic.c
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/gfx/legato/widget/checkbox/: legato_widget_checkbox.c legato_widget_checkbox_skin_classic.c
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/gfx/legato/widget/circle/: legato_widget_circle.c legato_widget_circle_skin_classic.c
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/gfx/legato/widget/circulargauge/: legato_widget_circular_gauge.c legato_widget_circular_gauge_skin_classic.c
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/gfx/legato/widget/circularslider/: legato_widget_circular_slider.c legato_widget_circular_slider_skin_classic.c
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/gfx/legato/widget/drawsurface/: legato_widget_drawsurface.c legato_widget_drawsurface_skin_classic.c
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/gfx/legato/widget/gradient/: legato_widget_gradient.c legato_widget_gradient_skin_classic.c
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/gfx/legato/widget/groupbox/: legato_widget_groupbox.c legato_widget_groupbox_skin_classic.c
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/gfx/legato/widget/image/: legato_widget_image.c legato_widget_image_skin_classic.c
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/gfx/legato/widget/imagerotate/: legato_widget_imagerotate.c legato_widget_imagerotate_skin_classic.c
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/gfx/legato/widget/imagescale/: legato_widget_imagescale.c legato_widget_imagescale_skin_classic.c
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/gfx/legato/widget/imagesequence/: legato_widget_imagesequence.c legato_widget_imagesequence_skin_classic.c
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/gfx/legato/widget/keypad/: legato_widget_keypad.c legato_widget_keypad_skin_classic.c
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/gfx/legato/widget/label/: legato_widget_label.c legato_widget_label_skin_classic.c
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/gfx/legato/widget/line/: legato_widget_line.c legato_widget_line_skin_classic.c
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/gfx/legato/widget/linegraph/: legato_widget_line_graph.c legato_widget_line_graph_skin_classic.c
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/gfx/legato/widget/list/: legato_widget_list.c legato_widget_list_skin_classic.c
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/gfx/legato/widget/listwheel/: legato_widget_listwheel.c legato_widget_listwheel_skin_classic.c
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/gfx/legato/widget/piechart/: legato_widget_pie_chart.c legato_widget_pie_chart_skin_classic.c
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/gfx/legato/widget/progressbar/: legato_widget_progressbar.c legato_widget_progressbar_skin_classic.c
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/gfx/legato/widget/radialmenu/: legato_widget_radial_menu.c legato_widget_radial_menu_skin_classic.c
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/gfx/legato/widget/rectangle/: legato_widget_rectangle.c legato_widget_rectangle_skin_classic.c
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/gfx/legato/widget/scrollbar/: legato_widget_scrollbar.c legato_widget_scrollbar_skin_classic.c
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/gfx/legato/widget/slider/: legato_widget_slider.c legato_widget_slider_skin_classic.c
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/gfx/legato/widget/textfield/: legato_widget_textfield.c legato_widget_textfield_skin_classic.c
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/gfx/legato/widget/touchtest/: legato_widget_touchtest.c legato_widget_touchtest_skin_classic.c
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/gfx/legato/widget/window/: legato_widget_window.c legato_widget_window_skin_classic.c
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/peripheral/ccl/: plib_ccl.c
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/peripheral/clock/: plib_clock.c
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/peripheral/cmcc/: plib_cmcc.c
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/peripheral/dmac/: plib_dmac.c
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/peripheral/evsys/: plib_evsys.c
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/peripheral/nvic/: plib_nvic.c
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/peripheral/nvmctrl/: plib_nvmctrl.c
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/peripheral/port/: plib_port.c
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/peripheral/sercom/i2c_master/: plib_sercom4_i2c_master.c
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/peripheral/tc/: plib_tc0.c
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/system/cache/: sys_cache.c
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/system/input/: sys_input.c sys_input_listener.c
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/system/int/src/: sys_int.c
    ../src/config/ili9488_rgb565_e54_cult_parallel_iar/system/time/src/: sys_time.c
